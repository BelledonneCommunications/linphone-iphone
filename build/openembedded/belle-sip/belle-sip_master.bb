require belle-sip.inc

SRCREV="0837e201b8add7b91c149e701a2b637d6c1da74a"
S = "${WORKDIR}/git"

PR="R1"


SRC_URI = "git://git.linphone.org/belle-sip.git;commit=0837e201b8add7b91c149e701a2b637d6c1da74a"
LIC_FILES_CHKSUM = "file://COPYING;md5=9f9938e31db89d55a796e86808c96848"
