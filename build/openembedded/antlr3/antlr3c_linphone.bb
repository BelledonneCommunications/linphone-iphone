require antlr3c.inc

SRCREV="f0dbcbbcd22a7fd9a479ff68d4daa9225fb2f3b1"
PR="R3"
SRC_URI = "git://git.linphone.org/antlr3.git"

LIC_FILES_CHKSUM= "file://COPYING;md5=13c502aaa9b2ca91d01a3aae44d899b4"
