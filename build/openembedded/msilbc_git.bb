PR = "r0"
SRC_URI = "git://git.linphone.org/msilbc.git;protocol=git"
SRCREV = "HEAD"
S = "${WORKDIR}/git"

require msilbc-common.inc
