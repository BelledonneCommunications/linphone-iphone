PR = "r1"
SRC_URI = "git://git.linphone.org/msx264.git;protocol=git"
SRCREV = "f1fd3d6be817dd5c1b8a46f68de04421f75cf056"
S = "${WORKDIR}/git"

require msx264-common.inc
