require libgsm.inc

PR = "${INC_PR}.0"

S = "${WORKDIR}/gsm-1.0-pl13/"

SRC_URI[md5sum] = "c1ba392ce61dc4aff1c29ea4e92f6df4"
SRC_URI[sha256sum] = "52c518244d428c2e56c543b98c9135f4a76ff780c32455580b793f60a0a092ad"
