PR = "r3"
SRC_URI = "git://git.linphone.org/mswebrtc.git;protocol=git"
SRCREV = "a9b5929928dd58299ceaed0aeb507c82bae80b55"
S = "${WORKDIR}/git"

require mswebrtc-common.inc
